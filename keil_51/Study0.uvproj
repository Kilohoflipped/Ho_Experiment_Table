# Keil uVision project Study0.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Study0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c uartFunctions.c adcFunctions.c pwmFunctions.c
